hostname="nuvlabox-${MACHINE}"